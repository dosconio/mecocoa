# Keil uVision project main.uvprojx, settings and files
target Target Main (6190000::V6.19::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=8 wLevel=3
  c define: _MCU_STM32H7x, _HIS_IMPLEMENT, _MCCA=0x1A072032, _DEBUG
  c misc: -fno-strict-aliasing -Wno-c++98-compat -Wno-old-style-cast -Wno-c++98-c++11-compat-binary-literal -Wno-extra-semi-stmt -Wno-deprecated-copy-with-user-provided-copy -Wno-c++98-compat-pedantic -Wno-keyword-macro -Wno-invalid-constexpr -Wno-empty-body -Wno-undefined-bool-conversion
  c include: D:\her\unisym\inc;..\h743-openedv
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\mcca.sct
  link misc: --keep="*(.init.rmod)"
  group Group Mcca
    ../../../../mecocoa/: memoman.cpp memoman-init.cpp memoman-swap.cpp message.cpp taskman.cpp taskman-new.cpp taskman-elf.cpp taskman-lock.cpp handler.cpp handler-tim.cpp console.cpp console-bcon.cpp console-init.cpp fileman.cpp filesys.cpp graphic.cpp schedul.cpp syscall.cpp sysinfo.cpp sysinfo-dev.cpp devsman.cpp devsman-usb.cpp threads.cpp graphic-touch.cpp userman.cpp
  group Group Syst
    D:/bin/ARM/STM32H7/: ustm32h7.lib
    ../../../: prehost.cpp
    ./: stm32h743.S stm32h743.startup.S
    ../../: main.cpp mem.cpp
  group Group Board
    ./: h743-openedv.cpp
  group Group Driv
    ../../../../devdriv/storage/: sdcard.cpp
    ../../../../devdriv/tty/: serial.cpp
    ../../../../devdriv/video/: video-ltdc.cpp
    ../../../../devdriv/touch/: touch-gtxxx.cpp
    ../../../../devdriv/: kboard.cpp
    ../../../../devdriv/usb/: usb_otg.cpp usb_storage.cpp
    ../../../../devdriv/bus/: bus-gpio.cpp
    ../../../../devdriv/mem/: fmc-sdram.cpp
  group Others
    ../../../../../unisym/lib/cpp/Device/: Video-VideoConsole2.cpp
    ../../../../depends/: desktop.cpp
    ../../../../devdriv/video/: video-classic.cpp
